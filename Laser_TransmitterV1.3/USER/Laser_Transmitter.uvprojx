# Keil uVision project Laser_Transmitter.uvprojx, settings and files
target Laser_Transmitter (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Laser_Transmitter +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\IR;..\APP;..\HARDWARE\EXIT;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\BLE_USART;..\HARDWARE\E2PROM;..\HARDWARE\OLED;..\HARDWARE\MOTOR_MS3111S;..\HARDWARE\STEPPER_MOTOR;..\HARDWARE\BEEP;..\HARDWARE\MYTIMER2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/IR/: ir.c
    ../HARDWARE/EXIT/: exit.c
    ../HARDWARE/TIMER/: mytimer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BLE_USART/: ble_usart.c
    ../HARDWARE/E2PROM/: e2prom.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/MOTOR_MS3111S/: motor_ms3111s.c
    ../HARDWARE/STEPPER_MOTOR/: stepper_motor.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/MYTIMER2/: mytimer2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group APP
    ../APP/: app.c
